# Keil uVision project BLE_iBeacon.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dingding +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\headers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.h main.c
  group HAL
    ./src/hal/: gpio_setup.c hal_radio.c tx_data_handler.c
  group Headers
    ./src/headers/: message_table.h network_characteristics.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.13.0
